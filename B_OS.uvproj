# Keil uVision project B_OS.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: B_OS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Device;.\Driver;.\system;.\USER_APP
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
    ./system/: OS_main.c
    ./USER_APP/: APP.c
  group device
    ./Device/: ds1302.c onewire.c D_i2c.c ultrasonic.c
  group driver
    ./Driver/: B_KEY.c B_LED.c B_smg.c FAC_operat.c
  group System
    ./system/: OS_timer.c
